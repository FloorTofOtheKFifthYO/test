# Keil uVision project car.uvprojx, settings and files
target car (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: car +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE\vega;..\SYSTEM\CAN;..\SYSTEM\EXTI;..\SYSTEM\flash;..\SYSTEM\TIM;..\HARDWARE\motorCtrl;..\HARDWARE\relay;..\HARDWARE\maxon;..\HARDWARE\radar;..\HARDWARE\LCD;..\HARDWARE\switch;..\HARDWARE\digit
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c param.c cmd.c configuration.c link_list.c cmd_func.c global.c
  group HARDWARE
    ../HARDWARE/motorCtrl/: motorCtrl.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/switch/: switch.c
    ../HARDWARE/digit/: digit.c
  group SENSOR
    ../HARDWARE/vega/: vega.c
    ../HARDWARE/radar/: radar.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/CAN/: can.c
    ../SYSTEM/EXTI/: exti.c
    ../SYSTEM/flash/: flash.c
    ../SYSTEM/TIM/: TIM.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_can.c stm32f4xx_fsmc.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group README
    ../: controller.txt
    ../SYSTEM/flash/: flash.md
